# Keil uVision project Slave_WS2812B.uvprojx, settings and files
target Slave_WS2812B (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L151C8xxA STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.2.0
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Slave_WS2812B +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L151xBA
  c include: ../USB_DEVICE/App;../USB_DEVICE/Target;../Core/Inc;../Drivers/STM32L1xx_HAL_Driver/Inc;../Drivers/STM32L1xx_HAL_Driver/Inc/Legacy;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../Drivers/CMSIS/Device/ST/STM32L1xx/Include;../Drivers/CMSIS/Include;../Drivers/SX127X;../Drivers/WS2812B
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application/MDK-ARM
    ./: startup_stm32l151xba.s
  group Application/User/Core
    ../Core/Src/: main.c stm32l1xx_it.c stm32l1xx_hal_msp.c
  group Application/User/USB_DEVICE/App
    ../USB_DEVICE/App/: usb_device.c usbd_desc.c usbd_cdc_if.c
  group Application/User/USB_DEVICE/Target
    ../USB_DEVICE/Target/: usbd_conf.c
  group Drivers/STM32L1xx_HAL_Driver
    ../Drivers/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal_pcd.c stm32l1xx_hal_pcd_ex.c stm32l1xx_ll_usb.c stm32l1xx_hal.c stm32l1xx_hal_rcc.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_flash.c stm32l1xx_hal_flash_ex.c stm32l1xx_hal_flash_ramfunc.c stm32l1xx_hal_gpio.c stm32l1xx_hal_dma.c stm32l1xx_hal_pwr.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_cortex.c stm32l1xx_hal_spi.c stm32l1xx_hal_tim.c stm32l1xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32l1xx.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group Drivers/SX127X
    ../Drivers/SX127X/: SX127X_Driver.c SX127X_Hal.c
  group Drivers/WS2812B
    ../Drivers/WS2812B/: colorset.c ws2812b.c
software components: CMSIS:CORE 4.3.0
